Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:49:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:49:42 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{BA060B11-C678-4E0D-BE55-AB7207008DCF}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:49:41 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:49:42 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:49:42 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Tip Ton, CONV_Vitra_DmstcChrs_TipTon:Tip Ton:413559
In: Level 1
Material: 04 white
Pset_ManufacturerTypeInformation - ModelReference: 44023000; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.1188 m2; Volume: 0.222041 m3
Materials and Finishes - ChairMainMaterial: 04 white
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_TipTon: Tip Ton; Family and Type: CONV_Vitra_DmstcChrs_TipTon: Tip Ton; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_TipTon: Tip Ton; Type Id: CONV_Vitra_DmstcChrs_TipTon: Tip Ton; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_TipTon; ConvergoRefNr: 0089-1812-0134-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Tip Ton by Edward Barber and Jay Osgerby is more than just an all-plastic chair with a distinctive contemporary design.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 20/12/2018
Identity Data(Type) - Collection: Tip Ton; Cost: 0; Description: Tip Ton by Edward Barber and Jay Osgerby is more than just an all-plastic chair with a distinctive contemporary design. Thanks to an alternative forward-tilt position, it also provides ergonomic seating. Tip Ton comes in a large range of colours. It can be stacked and is also 100 % recyclable.; Designer: Edward Barber & Jay Osgerby; Manufacturer: Vitra; Model: Tip Ton; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/189427/storage/master/download/Factsheet%20Tip%20Ton-EN.pdf; Type Name: Tip Ton; URL: https://www.vitra.com/en-un/living/product/details/tip-ton
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_TipTon; Features: Tip Ton is suitable for outdoor use.; Finish: Backrest, seat, base: polypropylene. Glides: polyethylene. Stacking: Tip Ton can be stacked up to 4 chairs high on the floor, up to 11 on a stacking trolley. A stacking trolley is separately available. Note: special additives retard the fading of colours due to UV radiation. However, if the chair is exposed to sunlight for prolonged periods, the colour may change over time. We recommend limited exposure to sunlight.; Grade: n/a; Material: Polypropylene.; ModelNumber: n/a; ModelReference: 44023000; Name: DmstcChrs_TipTon; ReplacementCost: n/a; Shape: Sculptured; Size: 509x555x786 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
